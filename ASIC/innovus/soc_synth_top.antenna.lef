

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO soc_synth_top 
  PIN clk 
    ANTENNAPARTIALMETALAREA 377.48 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1833.52 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 91.584 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3368 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 89.0327 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.32 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.609783 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 39.4826 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 214.32 LAYER met3 ;
    ANTENNAGATEAREA 94.128 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.7562 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 91.3096 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.610633 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 630.121 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3365.91 LAYER met4 ;
    ANTENNAGATEAREA 241.362 LAYER met4 ; 
    ANTENNAMAXAREACAR 47.0587 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 236.407 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.827434 LAYER via4 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 65.2124 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 325.675 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9555 LAYER met2 ; 
    ANTENNAMAXAREACAR 72.8232 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 359.493 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.24954 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.469 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.968 LAYER met3 ;
    ANTENNAGATEAREA 0.9555 LAYER met3 ; 
    ANTENNAMAXAREACAR 73.314 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 362.599 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.291403 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 14.7687 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 79.232 LAYER met4 ;
    ANTENNAGATEAREA 17.1165 LAYER met4 ; 
    ANTENNAMAXAREACAR 74.1769 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 367.228 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.406746 LAYER via4 ;
  END rst_n
  PIN rx 
    ANTENNAPARTIALMETALAREA 44.8028 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 223.853 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 8.1708 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.048 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.222 LAYER met4 ; 
    ANTENNAMAXAREACAR 90.195 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 462.151 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.591892 LAYER via4 ;
  END rx
  PIN tx 
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.3947 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.8655 LAYER met2 ;
  END tx
  PIN sclk 
    ANTENNADIFFAREA 0.891 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 63.0867 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 315.325 LAYER met2 ;
  END sclk
  PIN mosi 
    ANTENNADIFFAREA 0.891 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 53.7767 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 268.874 LAYER met2 ;
  END mosi
  PIN miso 
    ANTENNAPARTIALMETALAREA 61.1996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 305.837 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.9618 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.6 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met4 ; 
    ANTENNAMAXAREACAR 42.3139 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 219.27 LAYER met4 ;
    ANTENNAMAXCUTCAR 1.04286 LAYER via4 ;
  END miso
  PIN cs_n 
    ANTENNADIFFAREA 0.891 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 58.1839 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 290.812 LAYER met2 ;
  END cs_n
  PIN gpio_inout[9] 
    ANTENNAPARTIALMETALAREA 1.7485 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6345 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6972 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.132 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 26.398 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 120.123 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[9]
  PIN gpio_inout[8] 
    ANTENNAPARTIALMETALAREA 2.7145 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4645 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.7512 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.412 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.5917 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 111.706 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[8]
  PIN gpio_inout[7] 
    ANTENNAPARTIALMETALAREA 5.9625 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 29.7045 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.0312 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.802 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.1536 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 48.9008 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[7]
  PIN gpio_inout[6] 
    ANTENNAPARTIALMETALAREA 2.6809 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2965 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.8404 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.848 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 21.9202 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 97.7341 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[6]
  PIN gpio_inout[5] 
    ANTENNAPARTIALMETALAREA 2.7761 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7725 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.3632 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.354 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.2139 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 98.3452 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[5]
  PIN gpio_inout[4] 
    ANTENNAPARTIALMETALAREA 1.0401 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0925 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.5284 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.406 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.044 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 79.2897 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[4]
  PIN gpio_inout[3] 
    ANTENNAPARTIALMETALAREA 1.1689 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7365 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.8822 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.175 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.8663 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 128.401 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[3]
  PIN gpio_inout[2] 
    ANTENNADIFFAREA 0.4455 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8544 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.552 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.494 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 160.611 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.903968 LAYER via3 ;
  END gpio_inout[2]
  PIN gpio_inout[1] 
    ANTENNAPARTIALMETALAREA 0.1385 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5845 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.0904 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.108 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3472 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 85.4841 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.407937 LAYER via2 ;
  END gpio_inout[1]
  PIN gpio_inout[0] 
    ANTENNAPARTIALMETALAREA 3.6133 LAYER met1 ;
    ANTENNAPARTIALMETALSIDEAREA 17.9585 LAYER met1 ;
    ANTENNAPARTIALCUTAREA 0.0225 LAYER via ;
    ANTENNADIFFAREA 0.4455 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.4332 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.93 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.126 LAYER met2 ; 
    ANTENNAMAXAREACAR 34.2933 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 159.679 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.586508 LAYER via2 ;
  END gpio_inout[0]
END soc_synth_top

END LIBRARY
